# Keil uVision project smg_123.uvproj, settings and files
target Target 1 (MCS-51)
  device: M6032 Acer Labs
  cpu: IRAM(0-0xFF) CLOCK(33000000) XRAM (0-0xFF) MODDP2
  output: smg_123 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: smg_123.c
