# Keil uVision project shumaguanAdd1.uvproj, settings and files
target Target 1 (MCS-51)
  device: Core8051 Actel
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(12000000)
  output: shumaguanAdd1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: shumaguanAdd1.c
