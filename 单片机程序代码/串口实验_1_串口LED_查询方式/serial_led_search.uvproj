# Keil uVision project serial_led_search.uvproj, settings and files
target Target 1 (MCS-51)
  device: UT69RH051 Aeroflex UTMC
  cpu: IRAM(0-0xFF) CLOCK(20000000)
  output: serial_led_search +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: serial_led_search.c
