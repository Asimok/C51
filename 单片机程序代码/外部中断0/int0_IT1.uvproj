# Keil uVision project int0_IT1.uvproj, settings and files
target Target 1 (MCS-51)
  device: M6032 Acer Labs
  cpu: IRAM(0-0xFF) CLOCK(33000000) XRAM (0-0xFF) MODDP2
  output: int0_IT1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: int0_IT1.c
