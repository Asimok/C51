# Keil uVision project INT1_LED1-2.uvproj, settings and files
target Target 1 (MCS-51)
  device: M6032 Acer Labs
  cpu: IRAM(0-0xFF) CLOCK(33000000) XRAM (0-0xFF) MODDP2
  output: INT1_LED1-2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: INT1_LED1-2.c
