# Keil uVision project smg1357.uvproj, settings and files
target Target 1 (MCS-51)
  device: UT69RH051 Aeroflex UTMC
  cpu: IRAM(0-0xFF) CLOCK(20000000)
  output: smg1357 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: timer0_smg_1357.c
